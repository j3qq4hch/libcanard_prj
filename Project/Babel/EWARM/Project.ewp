# IAR project Project.ewp, settings and files
configuration STM32373C-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F373xB ST STM32F373xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F37X; HSE_VALUE=16000000; HSE_STARTUP_TIMEOUT=0x1000
  ICCARM.CCIncludePath2: ..\; ..\..\..\Libraries\CMSIS\Device\ST\STM32F37x\Include; ..\..\..\Libraries\STM32F37x_StdPeriph_Driver\inc; ..\..\..\Libraries\FreeRTOS\include; ..\FreeRTOS_portable; ..\..\..\Libraries\libcanard-master; ..\..\..\Libraries\libcanard-master\drivers\stm32
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32F373-EVAL.out
  ILINK.IlinkIcfFile: stm32f37x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../: system_stm32f37x.c
  group Doc
    ./: readme.txt
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F37x/Source/Templates/iar/: startup_stm32f37x.s
  group FreeRTOS
    ../../../Libraries/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS_portable/MemMang/: heap_1.c
    ../FreeRTOS_portable/: port.c portasm.s
  group libcanard
    ../../../Libraries/libcanard-master/: canard.c canard.h canard_internals.h
  group libcanard/driver
    ../../../Libraries/libcanard-master/drivers/stm32/: canard_stm32.c
  group StdPeriph_Drivers
    ../../../Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_adc.c stm32f37x_can.c stm32f37x_cec.c stm32f37x_comp.c stm32f37x_crc.c stm32f37x_dac.c stm32f37x_dbgmcu.c stm32f37x_dma.c stm32f37x_exti.c stm32f37x_flash.c stm32f37x_gpio.c stm32f37x_i2c.c stm32f37x_iwdg.c stm32f37x_misc.c stm32f37x_pwr.c stm32f37x_rcc.c stm32f37x_rtc.c stm32f37x_sdadc.c stm32f37x_spi.c stm32f37x_syscfg.c stm32f37x_tim.c stm32f37x_usart.c stm32f37x_wwdg.c
  group User
    ../: FreeRTOSConfig.h main.c misc.c stm32f37x_it.c
